# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\include;..\HARDWARE\LTC6804;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\CAN;..\HARDWARE\RS485;..\HARDWARE\INPUT_OUTPUT_CTRL;..\HARDWARE\BMS_STATE;..\HARDWARE\CAN;..\HARDWARE\EXTERNCAN;..\HARDWARE\GBT27930-2015;..\HARDWARE\ADC;..\HARDWARE\SOC;..\HARDWARE\FLASH;..\HARDWARE\ALARM;..\HARDWARE\SDIO;..\HARDWARE\STMFLASH;..\SYSTEM\tick;..\MALLOC;..\USMART;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\QUICKSORT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/tick/: tick.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RS485/: rs485_screen.c rs485_elect_meter.c rs485_insulation.c rs485_DTU.c
    ../HARDWARE/INPUT_OUTPUT_CTRL/: input_output_ctrl.c
    ../HARDWARE/BMS_STATE/: bms_state.c voltbalance.c
    ../HARDWARE/CAN/: can1.c can2.c
    ../HARDWARE/SPI/: spi_volacq.c LTC6804.c
    ../HARDWARE/EXTERNCAN/: extern_can.c
    ../HARDWARE/GBT27930-2015/: BMS.c Charger.c
    ../HARDWARE/ADC/: adc_cc.c adc_current.c adc_power.c adc_hv.c iic_fun.c iic_LTC2305.c
    ../HARDWARE/SOC/: soc_Vmin_EKF.c
    ../HARDWARE/ALARM/: faultalarm.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALOC
    ../MALLOC/: malloc.c
  group QUICKSORT
    ../HARDWARE/QUICKSORT/: quick_sort.c
